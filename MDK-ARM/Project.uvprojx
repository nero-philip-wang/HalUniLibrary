# Keil uVision project Project.uvprojx, settings and files
target PY32F002Ax5_Project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: PY32F002Ax5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F002Ax5
  c include: ..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include;..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ../Src/: system_py32f0xx.c u_clock.c u_pwm.c u_tim.c u_gpio.c u_adc.c u_timer.c u_i2c1.c
    ./: startup_py32f002xx.s
  group Application/User
    ../Src/: main.c py32f0xx_hal_msp.c py32f0xx_it.c u_app_ssd1306.c u_app_fonts.c
  group Doc
    ../: readme.md
software components: CMSIS:CORE 4.3.0, Drivers:PY32F0xx HAL Driver:ADC 1.1.5, Drivers:PY32F0xx HAL Driver:COMMON 1.1.5, Drivers:PY32F0xx HAL Driver:CORTEX 1.1.5, Drivers:PY32F0xx HAL Driver:FLASH 1.1.5, Drivers:PY32F0xx HAL Driver:GPIO 1.1.5, Drivers:PY32F0xx HAL Driver:I2C 1.1.5, Drivers:PY32F0xx HAL Driver:PWR 1.1.5, Drivers:PY32F0xx HAL Driver:RCC 1.1.5, Drivers:PY32F0xx HAL Driver:TIM 1.1.5, Drivers:PY32F0xx HAL Driver:UART 1.1.5
